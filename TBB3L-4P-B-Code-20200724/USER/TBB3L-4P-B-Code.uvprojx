# Keil uVision project TBB3L-4P-B-Code.uvprojx, settings and files
target TBB3L-4P-B-Code (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TBB3L-4P-B-Code +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\STM32F10x_FWLib\inc;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\RS485;..\HARDWARE\LeakTest;..\HARDWARE\TrSwitch;..\HARDWARE\MOTOR;..\HARDWARE\ADC;..\STM32F10x_FWLib\inc;..\HARDWARE\V9203;..\HARDWARE\EXTI;..\HARDWARE\TIMER;..\HARDWARE\WDG;..\HARDWARE\paraDispose;..\HARDWARE\variable;..\HARDWARE\AT_Deal
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LeakTest/: LeakTest.c
    ../HARDWARE/TrSwitch/: TrSwitch.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/V9203/: V9203.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/paraDispose/: ParaDispose.c
    ../HARDWARE/variable/: variable.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_iwdg.c
  group README
    ../: README.TXT
